FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"
SRC_URI += "file://0001-Added-M300-DTS-DTSI-files-and-updated-makefile.patch"
SRC_URI += "file://0001-Corrected-I2C-and-ECSPI-pin-allocations.patch"
